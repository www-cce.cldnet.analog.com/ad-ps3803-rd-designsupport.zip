# Allegro board AD-PS3803-RD Allegro Project File.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
POE_OUT+ on TOP: 45.47,62.07 50.8,62.07 50.8,37.56 48.64,37.56 48.64,40.99 48.26,41.37 45.21,41.37 45.21,46.83 44.7,47.34 35.94,47.34 35.94,51.15 45.34,51.15 46.99,52.8 46.99,57.38 48.51,58.9 48.51,60.96 48.06,61.41 45.87,61.41 45.47,61.82
POE_OUT+ on TOP: 41.91,21.18 37.21,21.18 36.45,20.42 10.92,20.42 8.89,18.39 8.89,4.29 35.94,4.29 35.94,14.32 38.73,17.12 41.66,17.12 41.91,17.37
POE_OUT+ on L3_PWR: 16,68.37 26.77,68.37 26.77,63.8 40.34,63.8 40.34,67.2 42.47,67.2 42.47,62.07 20.22,62.07 20.17,62.02 20.17,40.48 36.47,40.48 36.47,51.81 46.23,51.81 46.53,52.12 46.53,57.15 48.21,58.82 48.21,59.38 50.14,59.38 50.14,31.19 42.01,31.19 42.01,15.69 15.6,15.69 15.6,4.29 8.91,4.29 8.59,4.29 8.59,28.19 15.8,28.19 16,28.39
PWRGD on TOP: 42.67,61.57 45.31,61.57 46.23,60.65 47.5,60.65 47.5,58.77 47.14,58.42 44.58,58.42 44.58,61.19 44.45,61.31 42.67,61.31
PWRGD on TOP: 24.51,42.77 25.02,42.26 25.78,42.26 25.78,44.55 22.71,44.55 22.66,44.5 22.66,42.77
PWRGD on L3_PWR: 48.06,53.08 48.06,59.38 44.75,59.38 41.81,56.44 24.74,56.44 24.74,45.11 22.45,45.11 22.45,42.16 33.27,42.16 33.32,42.21 33.32,52.83 33.58,53.08
SPARE1 on TOP (solid shape): 73.72,53.09 71.17,53.09 71.17,55.84 73.72,55.84
SPARE1 on TOP: 71.17,52.93 74.68,52.93 74.68,53.69 74.88,53.9 76.1,53.9 76.1,55.62 71.17,55.62
SPARE2 on TOP (solid shape): 73.82,58.78 71.27,58.78 71.27,61.53 73.82,61.53
SPARE2 on TOP: 71.27,58.82 74.78,58.82 74.78,59.58 74.98,59.79 76.15,59.79 76.15,61.52 71.27,61.52
UNNAMED_3_CAP_I58_N2 on BOTTOM: 53.59,77.42 53.49,77.31 51.57,77.31 51.56,77.32 51.56,96.16 53.59,96.16
UNNAMED_3_CAP_I72_N1 on BOTTOM: 92.1,94.33 92.1,80.11 80.37,80.11 80.37,94.33
UNNAMED_4_DIOLED_I15_P on TOP: 22.99,58.59 22.99,54.15 26.03,54.15 26.03,58.59
UNNAMED_4_DIOSCHOTTKY_I5_P on TOP: 35.61,65.68 34.44,65.68 34.44,69.54 32.92,71.07 15.7,71.07 12.14,67.51 12.14,59.99 0.51,59.99 0.51,74.17 0.51,74.27 35.61,74.27
UNNAMED_4_ICLT4275_I46_HSGATE on TOP: 49.28,64.06 49.43,64.21 49.43,66.14 47.85,66.14 47.85,63.19 47.35,62.68 47.35,62.33 48.21,62.33 49.28,63.39
UNNAMED_7_ADLT8306_I16_VIN on TOP: 26.06,45.11 26.06,46.68 25.45,47.29 25.45,51.2 31.7,51.2 31.7,47.29 27.58,47.29 27.08,46.78 27.08,45.11
UNNAMED_7_CAP_I31_N1 on TOP: 38.15,44.95 38.15,41.35 43.94,41.35 43.94,44.95
UNNAMED_7_CAP_I31_N2 on TOP: 30.1,46.07 37.34,46.07 37.34,36.67 37.72,36.29 40.51,36.29 41.91,34.9 41.91,23.09 37.34,23.09 35.31,25.12 29.21,25.12 28.19,26.13 28.19,37.18 30.1,39.09
UNNAMED_7_CAP_I31_N2 on BOTTOM: 28.19,36.29 28.19,26.13 29.21,25.12 41.91,25.12 41.91,34.9 40.51,36.29
UNNAMED_7_CAP_I39_N1 on TOP: 101.85,26.77 77.6,26.77 77.22,26.39 77.22,23.21 76.96,22.96 70.36,22.96 70.36,15.97 101.73,15.97 101.85,16.1
UNNAMED_7_CAP_I61_N1 on TOP: 76.96,31.85 76.96,27.53 83.69,27.53 83.69,31.85
UNNAMED_7_CAPP_I46_N1 on TOP: 116.74,47.7 129.49,47.7 129.49,29.56 115.11,29.56 114.35,28.8 114.35,14.58 103.63,14.58 103.63,38.4 106.07,40.84 116.28,40.84 116.74,41.3
UNNAMED_7_DIOSCHOTTKY3P_I36_A1 on TOP: 65.53,30.96 75.69,30.96 75.69,23.97 69.67,23.97 68.78,23.09 65.53,23.09
UNNAMED_7_DIOSCHOTTKY_I29_N on TOP: 39.62,39.6 39.62,37.56 46.35,37.56 46.35,39.6
UNNAMED_7_RES_I24_N2 on TOP: 27.3,36.93 27.3,31.34 23.49,31.34 23.49,36.93
UNNAMED_7_RES_I25_N2 on TOP: 26.42,30.58 27.43,30.58 27.43,27.91 26.42,27.91
VPORTP on TOP (solid shape): 30.74,64.27 28.19,64.27 28.19,67.02 30.74,67.02
VPORTP on TOP (solid shape): 79.34,70.1 76.59,70.1 76.59,72.65 79.34,72.65
VPORTP on TOP (solid shape): 79.34,64.56 76.59,64.56 76.59,67.11 79.34,67.11
VPORTP on TOP (solid shape): 79.34,59.02 76.59,59.02 76.59,61.57 79.34,61.57
VPORTP on TOP (solid shape): 79.34,53.13 76.59,53.13 76.59,55.68 79.34,55.68
VPORTP on TOP: 65.74,63.75 69.8,63.75 69.8,61.36 66.29,61.36 66.19,61.46 64.92,61.46 64.92,62.94
VPORTP on TOP: 45.92,64.26 45.92,63.14 47.5,63.14 47.5,64.26
VPORTP on TOP: 76.61,72.64 76.61,53.18 80.11,53.18 80.11,72.64
VPORTP on TOP: 28.14,64.31 30.73,64.31 30.73,70.2 28.19,70.2 28.14,70.15
VPORTP on TOP: 50.6,63.85 51.82,63.85 51.92,63.95 51.92,67.56 51.97,67.61 55.63,67.61 55.63,61.67 52.48,61.67 51.71,62.43 50.6,62.43
VPORTP on L3_PWR: 77.11,74.27 80.11,74.27 80.11,52.52 75.69,52.52 75.69,60.6 75.29,61.01 67.21,61.01 67.21,61.82 67.16,61.87 27.13,61.87 27.13,70.21 44.14,70.21 46.84,67.51 77.01,67.51 77.11,67.61

## Text on the board
User.Comments: 4.    INSTALL P/N: SPN02SYBN-RC ON JP9~JP10 (PIN 1 AND PIN 2)
Ref Des/Silkscreen Top: POE_OUT- | POE_OUT+ | <70W> | <90W> | <25.5W> | <38.7W> | <52.7W> | IN FROM PSE,37V-57V | ETHERNET INTERFACE | AD-PS3803-RD | 25.5W PoE to 12V/2A Output Voltage Supply | RCLASS JUMPER | OUT TO PHY
PAGE_OUTLINE: TEST PROCESS | FAB NOTES REVISION: 2ND NOVEMBER 2022 | N/A | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 6.   BOW & TWIST NOT TO EXCEED 0.0075 INCHES (0.75%) PER LINEAR INCH AND SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP, | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | (X) WHITE | ( ) OTHER | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | (X)  ISOLA 370HR OR EQUIVALENT | ( )  ISOLA-FR408HR OR EQUIVALENT | ( )  ISOLA IS410 | ( )  MEGTRON 6 | ( )  NELCO-4000-13 | ( )  ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( )  OTHER ________________________ | ( ) FILLETS ALLOWED | (X) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | ( ) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | (X) GREEN | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.0003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 24. PANELIZATION: | 25.  MINIMUM DESIGN LINE WIDTH IS 0.008 INCH. | 26.  MINIMUM DESIGN LINE SPACING IS 0.00759 INCH. | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | ( )  NON-CONDUCTIVE EPOXY FILL ALL 0.XXXX INCHES DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | ( ) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | BOARDS TO BE SHIPPED IN SINGULATED AFTER FABRICATION PROCESS | SMOOTH EDGES AND FREE FROM BURRS AFTER DEPANELIZATION | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | B | ECR-119026 | 07FEB24 | D.BOISER | NOTES: | TOOLING: | FINISH: | MATERIAL: | TESTING: | MISCELLANEOUS: | 25.5W POE CLASS 2
BODY_CENTER: LABEL PLACEMENT INFORMATION | HALF SIZE LABELS ARE | AVAILABLE IN THE LIBRARY | PLACE WHEELIE BIN LOGO | TO SUIT THE LAYOUT. | PLACE ROHS COMPLIANT LOGO | TO SUIT THE LAYOUT OR | DELETE IF NOT REQ'D. | PLACE CHINA ROHS COMPLIANT | LOGO TO SUIT THE LAYOUT OR | 1.THE BOARD SIZE CAN BE ADJUSTED TO SUIT THE APPLICATION. | 2.THE MOUNTING HOLES CAN BE MOVED/REMOVED TO SUIT THE APPLICATION. | 3.THE FIDUCIALS CAN BE MOVED TO SUIT THE APPLICATION. | 4.ADJUST THE DIMENSIONS TO SUIT THE APPLICATION. | 5.ADD THE CORRECT LAYER STACKUP ON FAB2 BASED ON THE NO OF LAYERS ON THE PCB. | 6.THE ROHS COMPLIANT AND WHEELIE BIN LOGO'S CAN BE MOVED TO THE DESIRED LOCATION. | HALF SIZE VERSIONS OF THE LABELS ARE AVAILABLE IN THE LIBRARY. | NOTES FOR TEMPLATE USAGE. | GENERIC D-SIZE TEMPLATE BR-067706A
DIMENSION: REF | DIA MAX | TENTED VIA
User.22: L2 GND | 08-      -06
User.23: 08-      -07 | L3 PWR
User.45: FIGURE | SIZE | 10.0 | 35.0 | 40.0 | 63.0 | 100.0 | 213.0 | 125.0 | 127.0 | PLATED | NON-PLATED | FINISHED HOLES IN MILS | ALL UNITS ARE IN MILS | QTY | 932 | 16 | 20 | 4 | 8 | TOLERANCE/NOTES
